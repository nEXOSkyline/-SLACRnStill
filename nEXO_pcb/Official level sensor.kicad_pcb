# Repository nEXOSkyline/-SLACRnStill

File README.md:

# SLACRnStill

The distillation of Radon from the nEXO detector can improve its sensitivity. 
The distillation system is composed of a reboiler, condenser, Xe pump, and time 
projection chamber. 

This repository contains the code for the scale of the Radon distillation system along with the level sensor of the TPC.

## KiCad design nEXO_pcb/Official level sensor.kicad_pcb

Parts:
C1: 0.1uF1; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2: 47pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 68pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x04_Female; Amphenol Anytech YO 3.81mm 4p; DigikeyPN 609-3920-ND
J3, J5: M05PTH; 1X05
J4: 440055-4; TE_440055-4
J6, J7, J8, J9, J10: 70543-0003; SHDR4W97P0X254_1X4_1271X660X1143P; Mouser Part Number 538-70543-0003
MCU1: Teensy4.1; Teensy41
P2: Power; Socket_Strip_Arduino_1x08
P4: Analog; Socket_Strip_Arduino_1x08
P5: PWM; Socket_Strip_Arduino_1x10
P6: PWM; Socket_Strip_Arduino_1x08
P8, P9, P10, P11, P12, P13: CONN_01X01; Arduino_1pin
R2, R3, R4: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 82k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6: 39k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Teensy_Ethernet1: RJ45_LED; RJ45_Cetus_J1B1211CCD_Horizontal
U1: AD7151; MSOP-10_3x3mm_P0.5mm; DigikeyPN AD7151BRMZ-ND

Connections:
+3V3: MCU1.46 (3V3), P2.4
+5V: P2.5
/0(Rx0): P6.8
/1(Tx0): P6.7
/2(**): J5.4, P6.6
/3(**): J5.3, P6.5
/4(**): P6.4
/5(**): P6.3
/5V: MCU1.48 (VIN)
/6(**): P6.2
/7(**): P6.1
/8(**): P5.10
/9(**): P5.9
/10(**): P5.8
/11(**): P5.7
/12(**): P5.6
/13(**): P5.5
/A8: P4.1
/A9: P4.2
/A10: P4.3
/A11: P4.4
/A12: P4.5
/A13: P4.6
/A14: P4.7
/A15: P4.8
/AREF: P5.3
/IOREF: P2.2
/Reset: P2.3
/SCL: P5.1
/SDA: P5.2
/Vin: P2.8
GND: C2.2, C3.2, C6.2, J1.1, J2.2, J2.3, J3.1, J5.5, MCU1.47 (GND), P2.6, P2.7, P5.4, U1.1 (GND)
unnamed: C1.1, Teensy_Ethernet1.2, Teensy_Ethernet1.5
unnamed: C1.2, MCU1.64 (GND), Teensy_Ethernet1.8, Teensy_Ethernet1.9
unnamed: C2.1, R3.1, U1.6 (EXC)
unnamed: C3.1, R5.1, U1.4 (CIN)
unnamed: C6.1, R5.2, R6.1
unnamed: J1.2, U1.7 (OUT)
unnamed: J2.1, R6.2
unnamed: J2.4, R3.2
unnamed: J3.2, J4.4
unnamed: J3.3, J4.3
unnamed: J3.4, J4.2
unnamed: J3.5, J4.1
unnamed: J6.1, J7.1, J8.1, J9.1, J10.1
unnamed: J6.2, J7.2, J8.2, J9.2, J10.2
unnamed: J6.3, J7.3, J8.3, J9.3, J10.3
unnamed: J6.4, J7.4, J8.4, J9.4, J10.4
unnamed: MCU1.40 (18_A4_SDA), R4.2, U1.10 (SDA)
unnamed: MCU1.41 (19_A5_SCL), R2.2, U1.9 (SCL)
unnamed: MCU1.60 (R+), Teensy_Ethernet1.4
unnamed: MCU1.61 (LED), Teensy_Ethernet1.10
unnamed: MCU1.62 (T-), Teensy_Ethernet1.3
unnamed: MCU1.63 (T+), Teensy_Ethernet1.1
unnamed: MCU1.65 (R-), Teensy_Ethernet1.6
unnamed: R2.1, R4.1, U1.2 (VDD)
VCC: J5.2
VDD: J5.1

Notes on the sheet:
SCL
SDA
GND
Holes
VDD
Shield for Arduino Mega Rev 3

Board: 2 copper layers, 101.6 x 56.2 mm, 32 parts (0 on the bottom side), 28 nets.

## Commit log

2022-07-01 Add files via upload
    Second part of the PCB board separated from the breakout board
2022-07-01 Add files via upload
    Scale calibration code. Run by opening Anaconda powershell--> cd downloads-->dir-->scale_cal.py. Do not run in python.
2022-07-01 Add files via upload
    Components needed to build the pcb board in KiCAD
2022-08-04 Added calibrate and get_calc functions
2022-08-11 Changed calibration()
2022-08-11 Updated calibrate(); removed get_calc()
2022-08-12 fixed multiplier error, added index to calc_factor
2022-08-12 Adding the latest arduino code to git - loadCellScaler.zip
